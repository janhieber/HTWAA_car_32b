# Keil uVision project HTWAA_32b.uvprojx, settings and files
target HTWAA_32b Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: HTWAA_32b Configuration +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Test_GPIO\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Middlewares/MATLAB
    ../Test_GPIO/Src/: Test_GPIO_data.c Test_GPIO.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_dac.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
